[IBIS Ver]   5.0
[File Name]  EEsof_RX_Pass_Through.ibs
[File Rev]   1.0
[Component]  ibis_50ohm
[Manufacturer] Agilent Technologies, Inc.
[Package]
R_pkg  0.0   NA   NA
L_pkg  0.0   NA   NA
C_pkg  0.0   NA   NA
[Pin]   signal_name   model_name   R_pin L_pin  C_pin
2p   IBIS_50ohm_Rx_2p   ibis_50ohm_rx
2n   IBIS_50ohm_Rx_2n   ibis_50ohm_rx
[Diff_Pin] inv_pin vdiff tdelay_typ tdelay_min tdelay_max
2p   2n   NA   NA   NA   NA
[Model] ibis_50ohm_rx
Model_type Terminator
C_comp 0p 0p 0p
[Rpower] 1.0e9  1.0e9  1.0e9
[Temperature_Range] 25 125 0
[Voltage Range] 1.0 1.0 1.0
[Algorithmic Model]
Executable Windows_VisualStudio9.0.30729_32 EEsof_Rx_Pass_Through.dll EEsof_Rx_Pass_Through.ami
Executable Windows_VisualStudio9.0.30729_64 EEsof_Rx_Pass_Through_x64.dll EEsof_Rx_Pass_Through.ami
Executable Linux_gcc4.4.2_32 EEsof_Rx_Pass_Through_x32.so EEsof_Rx_Pass_Through.ami
Executable Linux_gcc4.4.2_64 EEsof_Rx_Pass_Through_x64.so EEsof_Rx_Pass_Through.ami
[End Algorithmic Model]
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[Ramp]
dV/dt_r 1.0/50p 1.0/50p 1.0/50p
dV/dt_f 1.0/50p 1.0/50p 1.0/50p
| Models and submodels in the file (1): ibis_50ohm_rx (Terminator)
